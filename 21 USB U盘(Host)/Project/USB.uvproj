# Keil uVision project USB.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\Common;..\FATFS\exfuns;..\FATFS\src;..\HanZi;..\Main;..\MALLOC;..\PICTURE;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\KEY;..\USER\LCD;..\USER\LED;..\USER\TF_SDIO;..\USER\SPI;..\USER\SRAM;..\USER\usart1;..\USER\W25QXX;..\HanZi;..\USER\MALLOC;..\USB\USB_APP;..\USB\STM32_USB_OTG_Driver\inc;..\USB\STM32_USB_HOST_Library\Core\inc;..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\USER\usart1
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/SPI/: spi.c
    ../USER/SRAM/: sram.c
    ../USER/usart1/: usart1.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/MALLOC/: malloc.c
    ../USER/TF_SDIO/: tfcard_sdio.c
  group HanZi
    ../HanZi/: HanZiUse.lib
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/: cc936.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_syscfg.c
  group Common
    ../Common/: common.c
  group USB_OTG
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
    ../USB/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_APP
    ../USB/USB_APP/: usbhost_user.c
