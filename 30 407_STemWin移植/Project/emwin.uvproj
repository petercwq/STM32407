# Keil uVision project emwin.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: emwin +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT = 1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\TIMER;..\USER\24C02;..\USER\TOUCH;..\USER\MALLOC;..\USER\SRAM;..\STM32F4_FWLIB\CMSIS\Include;..\STM32F4_FWLIB\CMSIS\Lib\ARM;..\EMWIN\Demo;..\EMWIN\STemWinLibrary522\Config;..\EMWIN\STemWinLibrary522\inc;..\EMWIN\STemWinLibrary522\Lib;..\EMWIN\STemWinLibrary522\OS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd_config.c
    ../USER/24C02/: 24c02.c
    ../USER/SRAM/: sram.c
    ../USER/MALLOC/: malloc.c
    ../USER/TIMER/: timer.c
    ../USER/usart1/: usart1.c
    ../USER/TOUCH/: touch.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c
  group Common
    ../Common/: common.c
  group DSP_LIB
    ../STM32F4_FWLIB/CMSIS/Include/: arm_math.h
    ../STM32F4_FWLIB/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group EMWIN_Config
    ../EMWIN/STemWinLibrary522/OS/: GUI_X.c
    ../EMWIN/STemWinLibrary522/Config/: GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c GUI_X_Touch_Analog.c
  group EMWIN_LIB
    ../EMWIN/STemWinLibrary522/Lib/: STemWin522_CM4_Keil.lib
  group EMWIN_Demo
    ../EMWIN/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
