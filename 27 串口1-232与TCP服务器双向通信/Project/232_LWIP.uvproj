# Keil uVision project 232_LWIP.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 232_LWIP +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\LCD;..\USER\LED;..\USER\usart1;..\USER\KEY;..\USER\DP83848;..\USER\LWIP_APP;..\STM32F4x7_ETH_Driver\inc;..\lwip_v1.3.2\doc;..\lwip_v1.3.2\port\STM32F4x7\arch;..\lwip_v1.3.2\port\STM32F4x7\Standalone;..\lwip_v1.3.2\src\api;..\lwip_v1.3.2\src\core\ipv4;..\lwip_v1.3.2\src\core\snmp;..\lwip_v1.3.2\src\include\ipv4\lwip;..\lwip_v1.3.2\src\include\lwip;..\lwip_v1.3.2\src\include\netif;..\lwip_v1.3.2\src\netif\ppp
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/KEY/: key.c
    ../USER/usart1/: usart1.c
    ../USER/DP83848/: stm32f4x7_eth_bsp.c
  group LWIP_APP
    ../USER/LWIP_APP/: netconf.c TCP_SERVER.C
  group LWIP
    ../lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip_v1.3.2/src/netif/: etharp.c loopif.c
    ../lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip_v1.3.2/port/STM32F4x7/Standalone/: ethernetif.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c
    ../STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Common
    ../Common/: common.c
