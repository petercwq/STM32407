# Keil uVision project RTC农历.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC农历 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\USER\MALLOC;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\KEY;..\USER\LCD;..\USER\LED;..\USER\SPI;..\USER\SRAM;..\USER\usart1;..\USER\W25QXX;..\HanZi;..\FATFS\src\option;..\FATFS\src;..\USER\TF_SDIO;..\FATFS;..\USER\RTC;..\USER\Lunar_Calendar
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group USER
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/RTC/: rtc.c
    ../USER/MALLOC/: malloc.c
    ../USER/Lunar_Calendar/: lunar_calendar.c
    ../USER/TF_SDIO/: tfcard_sdio.c
  group HanZi
    ../HanZi/: HanZiUse.lib
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_dma.c stm32f4xx_spi.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_exti.c
  group Common
    ../Common/: common.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/: cc936.c
