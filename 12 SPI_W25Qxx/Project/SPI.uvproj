# Keil uVision project SPI.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPI +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Common;..\Main;..\Startup_config;..\STM32F4_FWLIB\inc;..\USER\KEY;..\USER\LCD;..\USER\LED;..\USER\SPI;..\USER\W25QXX;..\USER\usart1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group USER
    ../USER/KEY/: key.c
    ../USER/LCD/: lcd.c
    ../USER/LED/: led.c
    ../USER/SPI/: spi.c
    ../USER/W25QXX/: w25qxx.c
    ../USER/usart1/: usart1.c
  group STM32F4_FWLIB
    ../STM32F4_FWLIB/src/: misc.c stm32f4xx_spi.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_usart.c
  group Common
    ../Common/: common.c
